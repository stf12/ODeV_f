# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L4R9AI ST STM32L4R9AI
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ST; STM32L4R9xx; USE_FREERTOS_8; USE_OS_SYSTICK; USE_STM32L4R9I_EVAL; USE_STM32L4R9I_EVAL_REVB; USE_GVO_390x390; USE_HAL_DRIVER; USE_IOEXPANDER; USE_LEDS; USE_OSPI_NOR; USE_BPP=16
  ICCARM.CCIncludePath2: ..\..\gui\include; ..\..\target\include; ..\..\platform\os; ..\..\generated\fonts\include; ..\..\generated\images\include; ..\..\generated\texts\include; ..\..\generated\gui_generated\include; ..\..\touchgfx\framework\include; ..\bsp\include\platform\core\arm\cortex-m\CMSIS; ..\bsp\include\platform\hal\ST\mcu\stm32l4cube; ..\bsp\include\platform\hal\ST\mcu\stm32l4cube\CMSIS; ..\bsp\include\platform\hal\ST\mcu\stm32l4cube\STM32L4xx_HAL_Driver; ..\bsp\include; ..\bsp\include\bsp; ..\bsp\source\vendor\STM32L4R9I_EVAL; ..\os\FreeRTOS8.2.0\Source\include; ..\os\FreeRTOS8.2.0\Source\portable\IAR\ST_CM7
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.ADefines: USE_FREERTOS_8; USE_OS_SYSTICK
  AARM.AUserIncludes: ..\..\platform\os
  OBJCOPY.OOCOutputFile: application.hex
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkIcfFile: application.icf
  ILINK.IlinkExtraOptions: --redirect _ZN8touchgfx12TextProvider10initializeEPKt9__va_list=_ZN8touchgfx12TextProvider10initializeEPKt8_VA_LIST; --redirect _ZN8touchgfx7Unicode14formatToStringEPttPKt9__va_list=_ZN8touchgfx7Unicode14formatToStringEPttPKt8_VA_LIST; --redirect _ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt9__va_list=_ZN8touchgfx3LCD13drawStringLTRERKNS_4RectES3_RKNS0_13StringVisualsEPKt8_VA_LIST; --redirect _ZNK8touchgfx4Font17getStringWidthLTREhPKt9__va_list=_ZNK8touchgfx4Font17getStringWidthLTREhPKt8_VA_LIST
  ILINK.IlinkAdditionalLibs: ..\..\touchgfx\lib\core\cortex_m4f\IAR\touchgfx_core.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/generated/fonts
    ../../generated/fonts/src/: ApplicationFontProvider.cpp Font_verdana_10_4bpp.cpp Font_verdana_20_4bpp.cpp Font_verdana_40_4bpp.cpp FontGetters.cpp Kerning_verdana_10_4bpp.cpp Kerning_verdana_20_4bpp.cpp Kerning_verdana_40_4bpp.cpp Table_verdana_10_4bpp.cpp Table_verdana_20_4bpp.cpp Table_verdana_40_4bpp.cpp
  group Application/generated/gui_generated/common
    ../../generated/gui_generated/src/common/: FrontendApplicationBase.cpp
  group Application/generated/gui_generated/main_screen
    ../../generated/gui_generated/src/main_screen/: mainViewBase.cpp
  group Application/generated/gui_generated/shortcutsscreen_screen
    ../../generated/gui_generated/src/shortcutsscreen_screen/: ShortcutsScreenViewBase.cpp
  group Application/generated/gui_generated/splashscreen_screen
    ../../generated/gui_generated/src/splashscreen_screen/: splashScreenViewBase.cpp
  group Application/generated/images
    ../../generated/images/src/: BitmapDatabase.cpp cursor_32.cpp edit-cut_32.cpp edit-paste_32.cpp left_arrow_small.cpp odev_f_logo.cpp
  group Application/generated/images/__designer
    ../../generated/images/src/__designer/: dark_buttons_round_edge_icon_button.cpp dark_buttons_round_edge_icon_button_pressed.cpp dark_buttons_round_edge_small.cpp dark_buttons_round_edge_small_pressed.cpp dark_icons_document_32.cpp dark_icons_done_32.cpp dark_icons_go_back_32.cpp dark_icons_go_next_32.cpp dark_pageindicator_dot_indicator_small_highlight.cpp dark_pageindicator_dot_indicator_small_normal.cpp
  group Application/generated/texts
    ../../generated/texts/src/: LanguageGb.cpp Texts.cpp TypedTextDatabase.cpp
  group Application/gui/common
    ../../gui/src/common/: FrontendApplication.cpp
  group Application/gui/main_screen
    ../../gui/src/main_screen/: mainPresenter.cpp mainView.cpp
  group Application/gui/model
    ../../gui/src/model/: Model.cpp
  group Application/gui/shortcutsscreen_screen
    ../../gui/src/shortcutsscreen_screen/: ShortcutsScreenPresenter.cpp ShortcutsScreenView.cpp
  group Application/gui/splashscreen_screen
    ../../gui/src/splashscreen_screen/: splashScreenPresenter.cpp splashScreenView.cpp
  group Application/main
    ../: main.cpp
  group Board/STM32L4R9I-EVAL
    ../bsp/source/: BoardConfiguration.cpp GPIO.cpp GraphicsInit.cpp
  group Board/STM32L4R9I-EVAL/BSP
    ../bsp/source/bsp/: STM32MCUInstrumentation.cpp STM32TouchController.cpp ts.c
  group Board/STM32L4R9I-EVAL/Vendor
    ../bsp/source/vendor/Components/ft3x67/: ft3x67.c
    ../bsp/source/vendor/Components/mfxstm32l152/: mfxstm32l152.c
    ../bsp/source/vendor/STM32L4R9I_EVAL/: stm32l4r9i_eval.c stm32l4r9i_eval_dsi_ts.c stm32l4r9i_eval_idd.c stm32l4r9i_eval_io.c stm32l4r9i_eval_ospi_nor.c stm32l4r9i_eval_ospi_ram.c stm32l4r9i_eval_sd.c stm32l4r9i_eval_sram.c stm32l4xx_it.c
  group MCU
    ../bsp/source/platform/hal/ST/mcu/stm32l4cube/: STM32DMA.cpp STM32HAL_DPI.cpp STM32HAL_DSI.cpp
  group MCU/stm32l4xx
    ../bsp/source/platform/hal/ST/mcu/stm32l4cube/iar/: startup_stm32l4r9xx.s
    ../bsp/source/platform/hal/ST/mcu/stm32l4cube/STM32L4xx_HAL_Driver/: stm32l4xx_hal.c stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal_can.c stm32l4xx_hal_comp.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dcmi.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma2d.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_dsi.c stm32l4xx_hal_firewall.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gfxmmu.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_hcd.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_irda.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_lptim.c stm32l4xx_hal_ltdc.c stm32l4xx_hal_ltdc_ex.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_opamp.c stm32l4xx_hal_opamp_ex.c stm32l4xx_hal_ospi.c stm32l4xx_hal_pcd.c stm32l4xx_hal_pcd_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_sai.c stm32l4xx_hal_sai_ex.c stm32l4xx_hal_sd.c stm32l4xx_hal_sd_ex.c stm32l4xx_hal_smartcard.c stm32l4xx_hal_smartcard_ex.c stm32l4xx_hal_smbus.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_swpmi.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_tsc.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c stm32l4xx_ll_gpio.c stm32l4xx_ll_i2c.c stm32l4xx_ll_lptim.c stm32l4xx_ll_lpuart.c stm32l4xx_ll_opamp.c stm32l4xx_ll_pwr.c stm32l4xx_ll_rcc.c stm32l4xx_ll_rng.c stm32l4xx_ll_rtc.c stm32l4xx_ll_sdmmc.c stm32l4xx_ll_spi.c stm32l4xx_ll_usb.c
    ../bsp/source/platform/hal/ST/mcu/stm32l4cube/CMSIS/: system_stm32l4xx.c
  group OS
    ../os/FreeRTOS8.2.0/: OSWrappers.cpp
  group OS/FreeRTOS8.2.0
    ../os/FreeRTOS8.2.0/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../os/FreeRTOS8.2.0/Source/portable/MemMang/: heap_4.c
    ../os/FreeRTOS8.2.0/Source/portable/IAR/ARM_CM4F/: port.c portasm.s
